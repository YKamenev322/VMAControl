# Keil uVision project pro2.uvproj, settings and files
target STM32 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: pro2 +hex
  AfterMake: fromelf --bin --output .\obj\pro2.bin .\obj\pro2.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: .\Inc;.\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;.\Middlewares\Third_Party\FreeRTOS\Source\include;.\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;.\Drivers\Eeprom_driver;.\Drivers\Modbus_driver;..\CommonSRC\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\CommonSRC\Drivers\CMSIS\Include;..\CommonSRC\Drivers\STM32F1xx_HAL_Driver\Inc;..\CommonSRC\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\CommonSRC\Inc
  memory RVCT4: ROM 0x8006400 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --debug
  group Startup
    ./: startup_stm32f103xe.s
    ./Inc/: main.h
  group Application/User
    ./Src/: freertos.c gpio.c i2c.c main.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_TIM.c stm32f1xx_it.c tim.c adc.c filter_sred.c vma.c dac.c
  group Drivers/CMSIS
    ../CommonSRC/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ./Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ./Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ./Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_1.c
  group Drivers/Eeprom
    ./Drivers/Eeprom_driver/: eeprom.c
  group ../CommonSRC/Drivers/STM32F1xx_HAL_Driver
    ../CommonSRC/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dac.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_dac_ex.c
  group CommonSRC/Src
    ../CommonSRC/Src/: flash.c usart.c
