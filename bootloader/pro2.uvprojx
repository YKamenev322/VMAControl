# Keil uVision project pro2.uvprojx, settings and files
target STM32 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pro2 +hex
  AfterMake: fromelf --bin --output .\obj\pro2.bin .\obj\pro2.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: .\Inc;..\CommonSRC\Inc;..\CommonSRC\Drivers\STM32F1xx_HAL_Driver\Inc;..\CommonSRC\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\CommonSRC\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\CommonSRC\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --debug
  group Startup
    ./: startup_stm32f103xe.s
    ./Inc/: main.h
  group Application/User
    ./Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
    ../CommonSRC/Src/: flash.c usart.c
  group Drivers/CMSIS
    ../CommonSRC/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../CommonSRC/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_uart.c
